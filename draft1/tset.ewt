<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\ADC.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\DHT11.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\ds1302.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\key.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Mp3Con.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Relay.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\UART.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\wt588d.c</name>
  </file>
</project>


